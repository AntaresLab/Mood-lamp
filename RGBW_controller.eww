<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\RGBW_controller.ewp</path>
    </project>
    <batchBuild />
</workspace>
